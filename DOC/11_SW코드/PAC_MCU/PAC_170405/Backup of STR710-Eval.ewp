# IAR project Backup of STR710-Eval.ewp, settings and files
configuration debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: STR710 ST STR710
  ICCARM.CCIncludePath2: ; str71x
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: str71x\lnkarm_flash.xcl
configuration RAM (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  ICCARM.CCIncludePath2: include
  XLINK.XclFile: str710_eval_ram.xcl
  group (top)
    ./: 71x_it.c pac.c pac.h
  group str71x
    str71x/: 71x_adc12.c 71x_adc12.h 71x_apb.c 71x_apb.h 71x_conf.h 71x_eic.c 71x_eic.h 71x_emi.c 71x_emi.h 71x_gpio.c 71x_gpio.h 71x_i2c.c 71x_i2c.h 71x_init.s 71x_it.h 71x_lib.c 71x_lib.h 71x_map.h 71x_pcu.c 71x_pcu.h 71x_rccu.c 71x_rccu.h 71x_tim.c 71x_tim.h 71x_type.h 71x_uart.c 71x_uart.h 71x_vect.s 71x_wdg.c 71x_wdg.h 71x_xti.c 71x_xti.h 7xx_flash.c 7xx_flash.h flash_conf.h flash_map.h init_table.s lnkarm_flash.xcl lnkarm_ram.xcl
